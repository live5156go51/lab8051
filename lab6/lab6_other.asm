	ORG 0000H
	AJMP MAIN
	ORG 000BH
	AJMP INTT0
	ORG 0030H
MAIN: ; 0113 0718
	MOV TMOD,#01H
	MOV TH0,#3CH
	MOV TL0,#0B0H
	SETB EA							 
	SETB ET0
	SETB TR0
	
	MOV 60H,#00H
	MOV 61H,#01H
	MOV 62H,#01H
	MOV 63H,#03H
	MOV 64H,#00H
	MOV 65H,#07H
	MOV 66H,#01H
	MOV 67H,#08H
	
	MOV R1,#60H
	MOV R2,#0AH
	MOV R3,#01H
	MOV R4,#80H
	
DISPLAY:
	MOV A,R3
	MOV R7,A
	MOV A,R1 ;
	MOV R0,A
	MOV A,R4
	MOV R6,A
	MOV DPTR,#TAB
LOOP3:	
	MOV A,@R0
	MOVC A,@A+DPTR
	MOV P2,A
	MOV P1,R6
	MOV A,R6	
	RL A
	MOV R6,A
	ACALL DELAY
	MOV P1,#00H
	INC R0
	DJNZ R7,LOOP3
	AJMP DISPLAY

INTT0:
	DJNZ R2,BACK
	MOV TH0,#3CH
	MOV TL0,#0B0H
	MOV R2,#0AH
	CJNE R4,#01H,INC1
	INC R1
	DEC R3
	CJNE R3,#0,BACK
	MOV R1,#60H
	AJMP INC1
	RETI
INC1:
	INC R3
	MOV A,R4
	RR A
	MOV R4,A	
BACK:
	RETI
	
DELAY: ; delay 2ms
	MOV B,#2
DL0:	
	MOV 70H,#0FAH ; 250*4 
DL1:
	NOP
	NOP
	DJNZ 70H,DL1
	DJNZ B,DL0
	RET

TAB:
	DB      0C0H, 0F9H, 0A4H, 0B0H  ;0, 1, 2, 3
	DB       99H,  92H,  82H, 0F8H  ;4, 5, 6, 7
	DB       80H,  90H,  88H,  83H  ;8, 9, A, B
	DB      0C6H, 0A1H,  86H,  8EH  ;C, D, E, F
	END