		ORG 0000H
		AJMP MAIN
		ORG 0003H
		AJMP INTT0
		ORG 0030H
MAIN:	
		MOV A,#00H
		MOV P0,#00H
		SETB EA
		SETB EX0
		SETB IT0
				
		SJMP $
INTT0:
		ACALL DELAY;����200ms
		JB P3.2,IEXIT
		DEC A
		CPL A
		MOV P0,A
		CPL A
		JNB P3.2,INTT0
		
IEXIT:	RETI

DELAY: 
		MOV B,#200	;delay 200ms
DL0:	
		MOV R1,#0FAH ; 250*4 
DL1:
		NOP
		NOP
		DJNZ R1,DL1
		DJNZ B,DL0
		RET
		
		END