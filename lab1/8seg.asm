	ORG 0000H
	AJMP MAIN
	ORG 0003H
	AJMP INTR0
	ORG 0030H
MAIN: 
	MOV	R0,#00H
	MOV A,#00H
	MOV DPTR,#TAB
	SETB EA
	SETB EX0
	SETB IT0
DISPLAY:	
	MOV A,R0
	MOVC A,@A+DPTR
	MOV	P0,A
	SJMP DISPLAY
	SJMP $
INTR0: INC R0
		RETI
TAB:
	DB 0FCH,60H,0DAH,0F2H,66H
	DB 0B6H,0BEH,0E0H,0FEH,0F6H
	DB 0EEH,3EH,9CH,7AH,9EH,8EH,00H
	END