	ORG 0000H
	AJMP MAIN
	ORG 0030H
MAIN:	MOV P0,#0FFH
	MOV A,#0FFH
	MOV P0,A
WAIT:   JB P1.0,WAIT
	ACALL DELAY
	JB P1.0,WAIT
	CPL A 
	MOV P0,A
	JB P1.0,WAIT
	ACALL DELAY1S
	JB P1.0,WAIT
WAIT1:
	MOV A,#0FEH
	;MOV R3,#07H
	ACALL DELAY1S
RRLED:
	
	RL A
	MOV P0,A
	ACALL DELAY100MS
	
	JB P1.0,RRLED
	ACALL DELAY
	JB P1.0,RRLED
	SJMP MAIN
	
	
	SJMP RRLED
DELAY:
		MOV R0,#0AH
DL0:	MOV R1,#0FAH
DL1:
	NOP
	NOP
	DJNZ R1,DL1
	DJNZ R0,DL0
	RET
DELAY100MS:
		MOV R0,#64H
DL100:	MOV R1,#0FAH
DL1001:
	NOP
	NOP
	DJNZ R1,DL1001
	DJNZ R0,DL100
	RET
DELAY1S:
		MOV B,#64H
DL1S:	MOV R0,#0AH
DL01S:	MOV R1,#0FAH
DL11S:
	NOP
	NOP
	DJNZ R1,DL11S
	DJNZ R0,DL01S
	DJNZ B,DL1S
	RET
	END  